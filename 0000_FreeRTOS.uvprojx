# Keil uVision project 0000_FreeRTOS.uvprojx, settings and files
target 0000_FreeRTOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 0000 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx
  c include: ..\0000_FreeRTOS;.\CMSIS\inc;.\USER\inc;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f407xx.s
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group USER
    ./USER/src/: main.c rcc_init.c led_init.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
